<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32L053R8_Nucleo-64.ewp</path>
  </project>
  <batchBuild />
</workspace>
